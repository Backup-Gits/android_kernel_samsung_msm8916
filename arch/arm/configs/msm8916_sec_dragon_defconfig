## arch/arm/hotplug/Kconfig
```kconfig
config MSM_SLEEPER
 	bool "CPU hotplug driver"
 	default n
 	help
 	  CPU hotplug driver
```
